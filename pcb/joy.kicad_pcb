# Repository Croktopus/joy

## KiCad design pcb/joy.kicad_pcb

File pcb/readme.md:

shoutout to spaceman for the RKJXM footprint! that diagram is a nightmare, don't envy him for having put that work in

Parts:
C1, C2: 4.7u; C_0603_1608Metric
C3, C4, C5, C7, C8, C9, C10, C11, C12: 0.1u; C_0603_1608Metric
C6: 10n; C_0603_1608Metric
C13, C14, C15: 1u; C_0603_1608Metric
D1: PRTR5V0U2X; SOT-143
EC1: Rotary_Encoder_Switch; ec11b
F1: PTC; Fuse_0805_2012Metric
H1, H2, H3, H4: M2.5; m2.5_pad_via
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
MF1: Alps_RKJXx; RKJXM2E13004
MF2: Alps_RKJXx; RKJXT1F42001
R1, R2, R3, R4, R5, R6, R10: 10k; R_0603_1608Metric
R7, R8: 5.1K; R_0603_1608Metric
SW1: SW_PUSH; SW_SPST_SKQG_WithStem
U1: STM32F072CBTx; LQFP-48_7x7mm_P0.5mm
U2: TLV75533PDBV; SOT-23-5
USB1: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-HandSoldering

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C14.2, C15.1, J2.5, U1.9 (VDDA), U1.24 (VDD), U1.36 (VDDIO2), U1.48 (VDD), U2.5 (OUT); also elsewhere on the board
+5V: C13.1, D1.4 (VCC), F1.2, U2.1 (IN), U2.3 (EN)
BOOT0: R10.2, U1.44 (BOOT0); also elsewhere on the board
D_N: D1.3 (I/O2), U1.32 (PA11), USB1.5 (DN2), USB1.7 (DN1)
D_P: D1.2 (I/O1), U1.33 (PA12), USB1.6 (DP1), USB1.8 (DP2)
EC1EA: C11.2, R5.2, U1.16 (PA6)
EC1EB: C12.1, R6.2, U1.17 (PA7)
EC1S1: EC1.S1, U1.18 (PB0)
EC1S2: EC1.S2, J1.4, U1.19 (PB1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.1, C10.2, C11.1, C12.2, C13.2, C14.1, C15.2, D1.1 (GND), EC1.C, H1.1, H2.1, H3.1, H4.1, J1.1, J2.2, MF1.9 (ECOM), MF1.10 (GND), MF2.9 (ECOM), MF2.10 (GND), R7.1, R8.1, R10.1, SW1.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.2 (GND), USB1.1 (GND), USB1.12 (GND), USB1.13 (SHIELD); also elsewhere on the board
MF1A: MF1.1 (A), U1.13 (PA3)
MF1B: MF1.2 (B), U1.14 (PA4)
MF1C: MF1.3 (C), U1.15 (PA5)
MF1COM: J1.2, MF1.8 (COM), U1.12 (PA2)
MF1D: MF1.4 (D), U1.5 (PF0)
MF1EA: C7.2, R1.2, U1.6 (PF1)
MF1EB: C8.1, R2.2, U1.10 (PA0)
MF1PUSH: MF1.7 (PUSH), U1.11 (PA1)
MF2A: MF2.1 (A), U1.27 (PB14)
MF2B: MF2.2 (B), U1.26 (PB13)
MF2C: MF2.3 (C), U1.25 (PB12)
MF2COM: J1.3, MF2.8 (COM), U1.28 (PB15)
MF2D: MF2.4 (D), U1.22 (PB11)
MF2EA: C9.2, R3.2, U1.31 (PA10)
MF2EB: C10.1, R4.2, U1.30 (PA9)
MF2PUSH: MF2.7 (PUSH), U1.29 (PA8)
NRST: J2.4, SW1.2, U1.7 (NRST); also elsewhere on the board
unnamed: EC1.A, R5.1
unnamed: EC1.B, R6.1
unnamed: F1.1, USB1.2 (VBUS), USB1.11 (VBUS)
unnamed: MF1.5 (EA), R1.1
unnamed: MF1.6 (EB), R2.1
unnamed: MF2.5 (EA), R3.1
unnamed: MF2.6 (EB), R4.1
unnamed: R7.2, USB1.4 (CC1)
unnamed: R8.2, USB1.10 (CC2)
SWCLK: J2.3, U1.37 (PA14)
SWDIO: J2.1, U1.34 (PA13)

Board: 2 copper layers, 50.0 x 99.0 mm, 40 parts (0 on the bottom side), 38 nets.

Other parts of the board:
BOOT0: SW_PUSH; SW_SPST_SKQG_WithStem
NRST: SW_PUSH; SW_SPST_SKQG_WithStem

Their connections:
+3V3: BOOT0.1; also elsewhere on the board
BOOT0: BOOT0.2; also elsewhere on the board
GND: NRST.1; also elsewhere on the board
NRST: NRST.2; also elsewhere on the board

## Commit log

2019-06-29 did everything lol
2019-06-29 attributions
2019-06-29 added reset switches
2019-06-30 added switches, redid routing, updated pins
2019-06-30 printing
2019-07-02 beautified schem
